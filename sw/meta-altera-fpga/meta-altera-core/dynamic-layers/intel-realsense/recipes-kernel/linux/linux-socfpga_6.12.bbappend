FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://realsense.scc"

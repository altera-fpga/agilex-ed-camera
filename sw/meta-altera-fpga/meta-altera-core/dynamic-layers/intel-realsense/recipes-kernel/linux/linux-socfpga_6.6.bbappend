FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://realsense.scc"
SRC_URI += "file://6.6-realsense-camera-formats.patch"


require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=83b7626b8c7a37263c6a58af8d19bee1"

ATF_VERSION = "v2.12.0"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "58e71a6f67a332c9e3cecf7fdaab80fbc3d40238"
